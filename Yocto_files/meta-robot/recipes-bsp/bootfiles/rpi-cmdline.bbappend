CMDLINE:append = " brcmfmac.feature_disable=0x82000"
